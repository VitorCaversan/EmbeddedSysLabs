# Keil uVision project lab02.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C1292NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab02
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1
  c include: C:\ti\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c
    ./src/Global/: global.c
    ./src/SysTick/: sysTick.c
    ./src/Leds/: leds.c
    ./src/Uart/: uart.c
    ./src/TempSens/: tempSens.c
    ./src/DCMotors/: dcMotor.c
  group Library
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
